# Keil uVision project testSTM32.uvproj, settings and files
target STM32F107VCT7 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: testSTM32 +hex
  c flags: Optim=1
  c define: STM32F10X_CL  USE_STDPERIPH_DRIVER USB_HOST USE_STM3210C_EVAL USE_USB_OTG_HS
  c include: ..\USER;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\LIB\CMSIS\CM3\CoreSupport;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\UI\include;..\UI\syscom\EventMgr;..\UI\syscom\SmMgr;..\UI\syscom\TimerMgr;..\UI\uicom;..\UI\uictrl;..\UI\uictrl\menu_main;..\UI\uictrl\menu_poweron;..\UI\syscom;..\DRV;..\LIB\STM32_USB_HOST_Library\Class\MSC\inc;..\LIB\STM32_USB_HOST_Library\Core\inc;..\LIB\STM32_USB_OTG_Driver\inc;..\LIB\fat_fs\inc;..\LIB\STM3210C_EVAL;..\LIB\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c usb_bsp.c usbh_usr.c spi_flash.c bkp.c
  group CMSIS
    ../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_exti.c
    ../LIB/common/: common.c
  group StartUp
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group mmi
    ../UI/include/: bits_types.h common_define.h
    ../UI/uictrl/: uimmi_ctrl.h uikeypad_ctrl.h uimmi_content.h uikeypad_ctrl.c uimmi_content.c uimmi_ctrl.c uimenu_ctrl.c uimenu_ctrl.h
    ../UI/syscom/EventMgr/: EventMgr.c
    ../UI/syscom/SmMgr/: SmMgr.c
    ../UI/syscom/TimerMgr/: SwTmrMgr.c
    ../UI/syscom/: syscom_util.c syscom_util.h
  group mmi_menu
    ../UI/uictrl/menu_poweron/: menu_welcome.c menu_pop_inputbox.c menu_pop_yesno.c menu_showcurve.c
    ../UI/uictrl/menu_main/: menu_channnel_switch.c menu_check_modecfg.c menu_main.c menu_search_option.c menu_setupoption.c menu_search_paramset.c menu_searchwarn.c menu_search_curve.c menu_bench.c
  group mmi_osd
    ../UI/uicom/: brush_print.h uicom_font.c ui_com_obj.c gui_osd_obj.c gui_menu_item.c brush_print.c gui_menu_item.h gui_osd_obj.h ui_com_obj.h
  group DRV
    ../DRV/: ad7705.c at45db041.c input_output.c lcd12864.c bsp.c xprintf.c rtc_time.c
  group UsbHostLib
    ../LIB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../LIB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group UsbOTG
    ../LIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group Fat32Fs
    ../LIB/fat_fs/src/: fattime.c ff.c
